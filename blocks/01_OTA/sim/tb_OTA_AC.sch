v {xschem version=3.4.8RC file_version=1.3}
G {}
K {}
V {}
S {}
F {}
E {}
C {blocks/01_OTA/xschem/OTA.sym} 200 -70 0 0 {name=x1}
